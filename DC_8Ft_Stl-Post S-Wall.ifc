Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], ExchangeRequirement[Structural, SurfaceGeometry], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:Off], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: DC_8Ft_Stl-Post S-Wall.ifc
Time: 2025-05-14T09:07:44
Author: FFC\cliffm
Organization: Structural Designer
Written by: IFC Parser version: 3.13.2
Made in: Tekla Structures 2022 Service Pack 10, IFC Export Version: 4.0.0.0 May 29 2023

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 1/2"Ø (4)
In: Undefined
Description: 1/2"Ø; Material: STEEL/F1554-GR.36
Tekla Common - Bottom elevation: -8"1/8; Top elevation: 1"7/8; Assembly/Cast unit Mark: TRD1; Phase: 1; Class: 19101
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.4 m2; Net surface area: 0 m2; Height: 12.7 mm; Width: 12.7 mm; Length: 254 mm
Pset_BeamCommon - LoadBearing: no; Reference: TRD1
BaseQuantities - Length: 254 mm; OuterSurfaceArea: 0.0101038 m2; NetVolume: 0.0000289685 m3; NetWeight: 0.227403 kg

# IfcBeam: 1/2"Ø HEX NUT (36)
In: Undefined
Description: 1/2"Ø HEX NUT; Material: STEEL/A563
Tekla Common - Assembly/Cast unit Mark: BP2; Phase: 1; Class: 19101
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 74.4 m2; Net surface area: 0 m2; Height: 22 mm; Width: 25.4 mm; Length: 12.3 mm
Pset_BeamCommon - LoadBearing: no; Reference: BP2
BaseQuantities - Length: 12.3031 mm; OuterSurfaceArea: 0.00201642 m2; NetVolume: 0.0000034537 m3; NetWeight: 0.0271116 kg
Name | Bottom elevation | Top elevation
4 x NUT | -7"7/8 | -7"3/8
24 x NUT | -7"1/2 | -7"
4 x NUT | 1"1/4 | 1"3/4
4 x NUT | -1/4 | 1/4

# IfcBeam: 1/2"Ø WASHER (8)
In: Undefined
Description: 1/2"Ø WASHER; Material: STEEL/F436
Tekla Common - Assembly/Cast unit Mark: BP3; Phase: 1; Class: 19101
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 119 m2; Net surface area: 0 m2; Height: 26.3 mm; Width: 27 mm; Length: 3.2 mm
Pset_BeamCommon - LoadBearing: no; Reference: BP3
BaseQuantities - Length: 3.175 mm; OuterSurfaceArea: 0.00122904 m2; NetVolume: 0.00000131548 m3; NetWeight: 0.0103266 kg
Name | Bottom elevation | Top elevation
4 x WASHER | 1"1/8 | 1"1/4
4 x WASHER | 1/4 | 3/8

# IfcBeam: BLOCK OFFSET (74)
In: Undefined
Description: BLOCK OFFSET; Material: MISCELLANEOUS/DURA-CRETE
Tekla Common - Phase: 1
Tekla Quantity - Weight: 72.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 1.7 m2; Height: 73 mm; Width: 2921 mm; Length: 212.7 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 212.725 mm; OuterSurfaceArea: 0.00000130217 m2; NetVolume: 0.0388115 m3; NetWeight: 68.9589 kg
Name | Bottom elevation | Top elevation | Assembly/Cast unit Mark = Reference | Class
6 x SLAT | 7'-5"1/2 | 8'-1"7/8 | SBO1 | 20001
6 x SLAT | 6'-9"1/2 | 7'-5"7/8 | SBO1 | 20001
6 x SLAT | 6'-1"1/2 | 6'-9"7/8 | SBO1 | 20001
6 x SLAT | 4'-9"1/2 | 5'-5"7/8 | SBO1 | 20001
6 x SLAT | 3'-5"1/2 | 4'-1"7/8 | SBO1 | 20001
6 x SLAT | 2'-1"1/2 | 2'-9"7/8 | SBO1 | 20001
6 x SLAT | 5'-5"1/2 | 6'-1"7/8 | SBO1 | 20001
6 x SLAT | 4'-1"1/2 | 4'-9"7/8 | SBO1 | 20001
6 x SLAT | 2'-9"1/2 | 3'-5"7/8 | SBO1 | 20001
6 x SLAT | 1'-5"1/2 | 2'-1"7/8 | SBO1 | 20001
6 x SLAT | 9"1/2 | 1'-5"7/8 | SBO1 | 20001
6 x SLAT | 1"1/2 | 9"7/8 | SBO1 | 20001
DND SLAT | 2'-6"1/2 | 3'-2"7/8 | SDND1 | 13
DND SLAT | 8"1/2 | 1'-4"7/8 | SDND1 | 13

# IfcBeam: FL1/4"X1 3/4" (14)
In: Undefined
Description: FL1/4"X1 3/4"; Material: STEEL/A36
Tekla Common - Phase: 1; Class: 20104
Tekla Quantity - Weight: 5.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 46 m2; Net surface area: 0.3 m2; Height: 44.5 mm; Width: 6.4 mm; Length: 2489.2 mm
Pset_BeamCommon - LoadBearing: no; Reference: f2
BaseQuantities - Length: 2489.2 mm; OuterSurfaceArea: 0.253467 m2; NetVolume: 0.000702595 m3; NetWeight: 5.51537 kg
Name | Bottom elevation | Top elevation | Assembly/Cast unit Mark
2 x SUPPORT PLATE | 1"3/8 | 8'-3"3/8 | DCP1
4 x SUPPORT PLATE | 1"3/4 | 8'-3"3/4 | DCP1
8 x SUPPORT PLATE | 1"3/4 | 8'-3"3/4 | DLP1

# IfcBeam: FL1/4"X10" (7)
In: Undefined
Description: FL1/4"X10"; Material: STEEL/A36
Tekla Common - Assembly/Cast unit Mark: APL1; Phase: 1; Class: 20031
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 43.5 m2; Net surface area: 0.1 m2; Height: 254 mm; Width: 6.4 mm; Length: 254 mm
Pset_BeamCommon - LoadBearing: no; Reference: APL1
BaseQuantities - Length: 254 mm; OuterSurfaceArea: 0.135533 m2; NetVolume: 0.000397252 m3; NetWeight: 3.11843 kg
Name | Bottom elevation | Top elevation
3 x ALIGNMENT PLATE | 1/2 | 3/4
4 x ALIGNMENT PLATE | -1/8 | 1/8

# IfcBeam: SLAT PAD (12)
In: Undefined
Description: SLAT PAD; Material: MISCELLANEOUS/NEOPRENE
Tekla Common - Assembly/Cast unit Mark: STP1; Phase: 1; Class: 21040
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0 m2; Height: 50.8 mm; Width: 3.2 mm; Length: 127 mm
Pset_BeamCommon - LoadBearing: no; Reference: STP1
BaseQuantities - Length: 127 mm; OuterSurfaceArea: 0.0140322 m2; NetVolume: 0.0000204838 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
6 x SLAT PAD | 1"7/16 | 1"9/16
4 x SLAT PAD | 3/4 | 7/8
SLAT PAD | 3/8 | 1/2
SLAT PAD | 1"1/16 | 1"3/16

# IfcColumn: 1/2"Ø (24)
In: Undefined
Description: 1/2"Ø; Material: STEEL/F1554-GR.36
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.4 m2; Net surface area: 0 m2; Height: 12.7 mm; Width: 12.7 mm; Length: 254 mm
BaseQuantities - Length: 254 mm; OuterSurfaceArea: 0.0101038 m2; NetVolume: 0.0000289685 m3; NetWeight: 0.227403 kg
Tekla Common - Bottom elevation: -7"3/4; Top elevation: 2"1/4; Assembly/Cast unit Mark: TRD1; Phase: 1; Class: 19101
Pset_ColumnCommon - LoadBearing: no; Reference: TRD1

# IfcColumn: 1/2"Ø HEX NUT (48)
In: Undefined
Description: 1/2"Ø HEX NUT; Material: STEEL/A563
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 74.4 m2; Net surface area: 0 m2; Height: 22 mm; Width: 25.4 mm; Length: 12.3 mm
BaseQuantities - Length: 12.3031 mm; OuterSurfaceArea: 0.00201642 m2; NetVolume: 0.0000034537 m3; NetWeight: 0.0271116 kg
Tekla Common - Assembly/Cast unit Mark: BP2; Phase: 1; Class: 19101
Pset_ColumnCommon - LoadBearing: no; Reference: BP2
Name | Bottom elevation | Top elevation
20 x NUT | 1"5/8 | 2"1/8
24 x NUT | 1/8 | 5/8
4 x NUT | 1"5/8 | 2"1/16

# IfcColumn: 1/2"Ø WASHER (48)
In: Undefined
Description: 1/2"Ø WASHER; Material: STEEL/F436
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 119 m2; Net surface area: 0 m2; Height: 26.3 mm; Width: 27 mm; Length: 3.2 mm
BaseQuantities - Length: 3.175 mm; OuterSurfaceArea: 0.00122904 m2; NetVolume: 0.00000131548 m3; NetWeight: 0.0103266 kg
Tekla Common - Assembly/Cast unit Mark: BP3; Phase: 1; Class: 19101
Pset_ColumnCommon - LoadBearing: no; Reference: BP3
Name | Bottom elevation | Top elevation
24 x WASHER | 1"1/2 | 1"5/8
24 x WASHER | 5/8 | 3/4

# IfcColumn: 18"Ø (7)
In: Undefined
Description: 18"Ø; Material: CONCRETE/3000-3500
Tekla Common - Bottom elevation: -4'-0"1/8; Top elevation: -1/8; Assembly/Cast unit Mark: CC1; Phase: 1; Class: 8
Tekla Quantity - Weight: 478.5 kg; Volume: 0.2 m3; Gross footprint area: 0.2 m2; Area per tons: 4.3 m2; Net surface area: 2.1 m2; Height: 457.2 mm; Width: 457.2 mm; Length: 1219.2 mm
Pset_ColumnCommon - LoadBearing: no; Reference: CC1
BaseQuantities - Length: 1219.2 mm; OuterSurfaceArea: 2.07564 m2; NetVolume: 0.199145 m3; NetWeight: 478.5 kg

# IfcColumn: C3X3.5 (3)
In: Undefined
Description: C3X3.5; Material: STEEL/A36
Tekla Common - Assembly/Cast unit Mark: DCP1; Phase: 1; Class: 20103
Tekla Quantity - Weight: 13.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 50.1 m2; Net surface area: 0.7 m2; Height: 76.2 mm; Width: 34.9 mm; Length: 2482.9 mm
Pset_ColumnCommon - LoadBearing: no; Reference: c1
BaseQuantities - Length: 2482.85 mm; OuterSurfaceArea: 0.686638 m2; NetVolume: 0.00156012 m3; NetWeight: 12.247 kg
Name | Bottom elevation | Top elevation
DC CHANNEL | 1"5/8 | 8'-3"3/8
2 x DC CHANNEL | 2" | 8'-3"3/4

# IfcColumn: W6X9 (7)
In: Undefined
Description: W6X9; Material: STEEL/A572-GR.50
Tekla Common - Phase: 1; Class: 20102
Tekla Quantity - Weight: 33.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 51.3 m2; Net surface area: 1.7 m2; Height: 149.2 mm; Width: 101.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: w1
Name | Bottom elevation | Top elevation | Assembly/Cast unit Mark | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
DC CORNER POST | 1"1/8 | 8'-3"3/8 | DCP1 | 2495.6 | 2495.55 | 1.73848 | 0.00407539 | 31.9918
2 x DC CORNER POST | 1"1/2 | 8'-3"3/4 | DCP1 | 2495.6 | 2495.55 | 1.73848 | 0.00407539 | 31.9918
DC LINE-POST | 1"1/2 | 8'-3"3/4 | DLP1 | 2495.9 | 2495.95 | 1.73876 | 0.00407603 | 31.9969
3 x DC LINE-POST | 1"1/2 | 8'-3"3/4 | DLP1 | 2495.6 | 2495.55 | 1.73848 | 0.00407539 | 31.9918

# IfcCovering: HDG (28)
In: Undefined
Material: Undefined/Undefined

# IfcCovering: HOT DIP GALVANIZED (7)
In: Undefined
Material: Undefined/Undefined

# IfcMechanicalFastener: Bolt assembly (21)
In: Undefined
Material: Undefined
Tekla Bolt - Washer count: 0; Washer type: PLAIN; Nut count: 0; Nut type: HEAVY_HEX; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Site
Name | NominalDiameter (mm) | NominalLength (mm) | Washer diameter (mm) | Washer name | Nut name | Bolt hole diameter (mm) = Bolt size (mm) | Bolt count | Bolt length (mm) | Bolt standard | Bolt Name
7 x Bolt assembly | 12.7 | 19.05 | 12.7 | WASHER 1/2" HARDENED PLAIN | NUT 1/2" HEAVY HEX | 19 | 4 | 19 | A325N | BOLT 1/2"DIA A325 1"
7 x Bolt assembly | 19.05 | 4.7625 | 19 | WASHER 3/4" HARDENED PLAIN | NUT 3/4" HEAVY HEX | 19 | 1 | 4.8 | ASTM F1852 | BOLT 3/4"DIA F1852 1"
7 x Bolt assembly | 12.7 | 6.35 | 12.7 | WASHER 1/2" HARDENED PLAIN | NUT 1/2" HEAVY HEX | 15.9 | 4 | 6.3 | ASTM F1852 | BOLT 1/2"DIA F1852 1"

# IfcPlate: FL3/4"X10" (7)
In: Undefined
Description: FL3/4"X10"; Material: STEEL/A36
Tekla Common - Phase: 1; Class: 20101
Tekla Quantity - Weight: 9.6 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 15.4 m2; Net surface area: 0.1 m2; Height: 254 mm; Width: 19.1 mm; Length: 254 mm
Pset_PlateCommon - LoadBearing: no; Reference: f1
BaseQuantities - Width: 254 mm; NetArea: 0.148387 m2; GrossArea: 0.064516 m2; CrossSectionArea: 0.000362903 m2; NetVolume: 0.00122903 m3; GrossVolume: 0.00122903 m3
Name | Bottom elevation | Top elevation | Assembly/Cast unit Mark
BASE PLATE | 3/8 | 1"1/8 | DCP1
2 x BASE PLATE | 3/4 | 1"1/2 | DCP1
4 x BASE PLATE | 3/4 | 1"1/2 | DLP1
